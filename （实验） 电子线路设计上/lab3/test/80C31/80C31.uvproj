# Keil uVision project 80C31.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C32E Atmel
  cpu: IRAM(0-0xFF)  CLOCK(30000000)
  output: 80C31 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 test.c
