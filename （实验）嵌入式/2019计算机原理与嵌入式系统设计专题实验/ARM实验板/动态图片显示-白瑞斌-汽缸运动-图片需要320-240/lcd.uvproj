# Keil uVision project lcd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC710 Nuvoton
  cpu: IRAM(0xFFE00000-0xFFE01FFF) ROM1(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: lcd
  c flags: Optim=1
  asm define: EBI_NOINIT
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x800000 size 0x800000
  memory RVCT9: RAM 0xffe00000 size 0x2000
  group Source Group 1
    ./: W90P710.s GLCD.c GLCD.h lcd.c Background.c ARM_Ani.c IRQ.c pic4.c pic1.c pic2.c pic3.c pic7.c pic5.c pic6.c
