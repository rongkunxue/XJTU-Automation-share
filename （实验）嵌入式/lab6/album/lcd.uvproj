# Keil uVision project lcd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC710 Nuvoton
  cpu: IRAM(0xFFE00000-0xFFE01FFF) ROM1(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: lcd
  c flags: Optim=1
  asm define: EBI_NOINIT
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x800000 size 0x800000
  memory RVCT9: RAM 0xffe00000 size 0x2000
  group Source Group 1
    ./: GLCD.c LCD.c Picture.c GLCD.h W90P710.s picture2.c picture0.c picture3.c picture4.c picture5.c
