# Keil uVision project lcd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC710 Nuvoton
  cpu: IRAM(0xFFE00000-0xFFE01FFF) ROM1(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: lcd
  c flags: Optim=1
  asm define: EBI_NOINIT
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x800000 size 0x800000
  memory RVCT9: RAM 0xffe00000 size 0x2000
  group Source Group 1
    ./: W90P710.s GLCD.c GLCD.h lcd.c Background.c ARM_Ani.c IRQ.c bz001.c bz002.c bz003.c bz004.c bz005.c bz006.c bz007.c bz008.c bz009.c bz010.c bz011.c bz012.c bz013.c bz014.c bz015.c bz016.c bz017.c bz018.c bz019.c
