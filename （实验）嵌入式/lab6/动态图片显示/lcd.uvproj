# Keil uVision project lcd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC710 Nuvoton
  cpu: IRAM(0xFFE00000-0xFFE01FFF) ROM1(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: lcd
  c flags: Optim=1
  asm define: EBI_NOINIT
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x800000 size 0x800000
  memory RVCT9: RAM 0xffe00000 size 0x2000
  group Source Group 1
    ./: W90P710.s GLCD.c GLCD.h lcd.c Background.c ARM_Ani.c IRQ.c ren001.c ren002.c ren003.c ren004.c ren005.c ren006.c ren007.c ren008.c ren009.c ren010.c ren011.c ren012.c ren013.c ren014.c ren015.c ren016.c ren017.c ren018.c
