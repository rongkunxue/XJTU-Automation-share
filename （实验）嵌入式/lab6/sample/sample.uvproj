# Keil uVision project sample.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC710 Nuvoton
  cpu: IRAM(0xFFE00000-0xFFE01FFF) ROM1(0x0-0x3FFFFF) CLOCK(15000000) CPUTYPE(ARM7TDMI)
  output: sample +hex
  c flags: Optim=1
  memory RVCT1: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0xffe00000 size 0x2000
  group Source Group 1
    ./: W90P710.s main.c
